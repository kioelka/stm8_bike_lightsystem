# IAR project STM8_kelka.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: src
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: STM8_kelka.bin
  ILINK.IlinkOutputFile: STM8_kelka.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: bike.c bike.h main.c
